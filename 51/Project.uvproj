# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DHT11.c DHT11.h Delay.c Delay.h UART.c UART.h TypeDef.h AT24C02.h AT24C02.c oled.c oled.h oledWENZI.h
